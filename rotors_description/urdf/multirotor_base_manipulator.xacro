Commit message: working on for manipulator

File: rotors_description/urdf/multirotor_base_manipulator.xacro (robot description, xacro)
@@ -47,5 +47,4 @@
           <cylinder radius="0.025" length="0.01"/>
         </geometry>
-        <material name="white"/>
       </visual>
     </link>
